<?xml version="1.0" encoding="utf-8"?>
<!--
This file was saved with a tool from Vector Informatik GmbH
-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-0-3.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="01C85E8B-DC16-48E4-B0AC-764E55C6F2EA">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="0606AF74-FBD4-46AC-AF4D-8779D45E9B73">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3EF05883-DEAE-48B3-B821-C281A6D05C4F">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7182F3E4-50B7-4F5E-A37C-C1F31AF25970">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="0A4FE2DB-8742-4CEA-9A11-854FED33C4AE">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2E5392ED-A6FD-44D8-B43F-9ABD13D8A153">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="CF90235C-A77F-410E-AC0F-E9E957F47290">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="99FD5429-5806-4EA1-858E-83B511F58EBC">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="F8F24A00-7B39-46F7-8710-6547B817FB2E">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="54D62731-74A9-4E9E-A96B-D40588FABD43">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3CD8CE50-C3EA-481C-A3A4-CCE1D8C86677">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="545F0A4E-8CAC-4330-994E-2C09B2B85133">
          <SHORT-NAME>PlatformTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D46ABCA2-EBCA-426C-BE98-CA74AB7B7746">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EEE89A60-E748-4A7D-85A1-89526B887CDD">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="44D34F8C-7EB4-404D-AC90-E4EC7B2CE86C">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="528E36E5-A3D6-47E1-9C00-EE66B992A407">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="38A56F4A-09D4-4351-B50C-735B1D3DC424">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DF9CDDC3-102A-4283-A461-40C1E95FD26E">
      <SHORT-NAME>Nexteer</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="869B7B07-52C9-4661-BD35-747C27731B63">
          <SHORT-NAME>Calibrations</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="62A31D46-E813-44DC-9A1C-03F931C287CD">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A96F0713-E97F-4677-BDA9-B2836A0CF99E">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F5BC336D-7F68-431F-A132-1C9964947D8C">
          <SHORT-NAME>DataTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="172B6DD5-F18F-4595-BAB7-F2215C69DE97">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="69008EEE-C7E6-4D44-B2DF-22752EB17695">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E93F6EFF-381F-456B-9B7F-EC0F9F7B7687">
          <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6129620B-B6E6-4A91-8F1B-96DD4AEADBB0">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D5B4E095-8F3D-418F-AB06-BD30490B5310">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1E7D7F35-F726-4B8C-A3E9-5AEF6EEEADC5">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="2EDA0C49-69B9-4FEF-9E7D-FDCB825743EF">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>