<?xml version="1.0" encoding="utf-8"?>
<!--
This file was saved with a tool from Vector Informatik GmbH
-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-0-3.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="B7EDD042-4044-414C-9970-1C2313A88AC7">
      <SHORT-NAME>ActiveEcuC</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="896574DF-76FC-4E03-9A3E-1DFCC8847B48">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="5F144001-E506-4A42-83D1-409FD1597D0C">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="792F5543-68BA-4267-8191-54457ECEEF03">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6599C7B6-F5C6-4909-BA09-50F841E002BD">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="41039A61-3ACF-436C-B629-24FA5AD26D96">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="36EF884D-CF29-45D2-908D-F715472EC790">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="4D671136-8D25-4EF8-A7C9-12FA25EC7983">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="BBFA75BF-B3BD-4CBE-8CAA-FD7C3EB2DE41">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BEF6792A-7823-4A1F-8A87-FBCE081E54FF">
      <SHORT-NAME>Cluster</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6D7DBD72-A7F4-417D-9177-39B35CFBDFF2">
      <SHORT-NAME>ComponentType</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="E4C34525-D250-4A47-87C6-B72C511DC600">
          <SHORT-NAME>DataTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="07133817-EF0C-4B5A-B030-39952224EA16">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="69a0497a-eb74-4b75-aca4-88f509b3d466">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7182F3E4-50B7-4F5E-A37C-C1F31AF25970">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="51E7A631-B6C6-4918-B4D3-6B5AF3F273F7">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="8E520F40-A137-40E0-B18E-C81476E0E16D">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E43311E4-8288-449A-8F30-411A12D8F17A">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D198C95D-B9E9-4228-BFEE-1B80A2F6CBDE">
      <SHORT-NAME>DataConstrs</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9FAEC9C6-4D27-4F27-A687-7D77CB75704E">
      <SHORT-NAME>DataDictionary</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="DA04B707-D521-4B2C-AADD-7D4714F32114">
          <SHORT-NAME>Calibrations</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4F5AB530-BF28-43CB-8431-BC88B226C54F">
          <SHORT-NAME>ComponentTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="E43448DC-D38C-41F6-990C-2D7B784095E8">
              <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2C4C0C2D-2518-45A8-91EC-A10A5DF0BF36">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F54CE3F2-5359-402D-A92C-C7F3144442DC">
          <SHORT-NAME>DataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4E607466-A9B3-4D09-96A0-03114A9AC8E9">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="53371837-B3A1-4D96-A457-1B62DF903905">
      <SHORT-NAME>DataType</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B8CD42C6-E686-4D68-B4CE-9A006813279D">
      <SHORT-NAME>DataTypeMapping</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="99FD5429-5806-4EA1-858E-83B511F58EBC">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="B73F1472-8CC6-45F8-ADDE-6B4254CF2417">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B01994E8-2BCA-4496-B000-60E2B71BA1D9">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3CD8CE50-C3EA-481C-A3A4-CCE1D8C86677">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="545F0A4E-8CAC-4330-994E-2C09B2B85133">
          <SHORT-NAME>PlatformTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="86045E6C-9C2A-4C68-9B3C-A6B09EEE430D">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="FDC1851A-DBD0-4C21-BDE8-348BA17992C9">
      <SHORT-NAME>DaVinci</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="B86907E1-22C9-40AC-8117-C8AC4C8119CB">
          <SHORT-NAME>PKG_Cluster_CAN00</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="5CAE5749-2485-4B63-BAF4-DB564A84A548">
          <SHORT-NAME>PKG_ECU</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A700DF02-38DF-4A32-A082-E30BB066882C">
      <SHORT-NAME>ECU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8F817EA8-F78D-49A7-838B-6205BEA093DE">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="685B6738-5B62-40EE-A7A3-A83C28A89A5E">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="45D7C8BA-CAA8-42BD-BB22-8DA8FD4383DA">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="ea7a6fb9-6816-4fc0-8406-806b7ba11830">
      <SHORT-NAME>MICROSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="8a170c04-e05d-4eb4-8da4-33679ae8612d">
          <SHORT-NAME>Dem_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="ba193f71-06c8-4c12-8280-8b5c2fb55b89">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="b42ba5e7-74db-4ed7-983b-1bf927da7bef">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="18ef0360-4a1e-4d7a-9b13-c749548638f3">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="ee2b4c41-3bfb-4345-b9fb-eb1ed0753c67">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="9a21bc63-ed31-47a0-88d6-9eff17f9d39e">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="75267076-56af-43bc-bb0c-71f1a742efcf">
          <SHORT-NAME>NvM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="b52800ea-fc72-43bc-8a9f-ba33c8f4ed33">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="eee1dc16-dd67-4788-b511-a5df357d9bb2">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="6307de35-5931-4927-8eeb-e0091c62c958">
                  <SHORT-NAME>BaseTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="641f7da7-07de-49e8-8942-6e2b736d3192">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="5150bf1c-c9a2-4d50-8a48-af426deda450">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="90282922-c42b-426c-983b-c0b934a8b659">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="5DBF4D1B-915D-486D-90AB-CA301BBFDDC5">
      <SHORT-NAME>MICROSAR_SWCS_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="2f43fd6e-faf5-4d43-b705-c6ce0ac34a4d">
          <SHORT-NAME>BswM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="e89ea87b-d251-4345-bb70-3ab943b38c07">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="baac57d7-9813-453e-a636-793ed058dcd2">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="1e38bb07-0059-4f9c-b242-264b74a5bb08">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="6166f64b-892c-4e58-bdc5-3ee0d078bd46">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B781E3CB-9C26-4E14-8457-D16CC8EEB633">
          <SHORT-NAME>Dem_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="ba193f71-06c8-4c12-8280-8b5c2fb55b89">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="b42ba5e7-74db-4ed7-983b-1bf927da7bef">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="18ef0360-4a1e-4d7a-9b13-c749548638f3">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="ee2b4c41-3bfb-4345-b9fb-eb1ed0753c67">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="17DE5AC1-D806-4242-8416-9CECBF94E1FB">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="e713dab8-4828-4166-924c-98b8bb6df1c4">
          <SHORT-NAME>Det_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="af7765cb-6bb8-4b21-baf9-709be933a70a">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="663c6e7e-2abc-4200-8403-e17a4b9f4c88">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="19ec659e-b1ee-4d46-9550-f61e0594ec41">
          <SHORT-NAME>IoHwAb_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="db587608-7c63-4db6-aa1e-d72630b260e9">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="1aab730f-43ff-4488-b553-232365398ce3">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="3a19bc29-716e-4621-8e16-2083b5013cb0">
                  <SHORT-NAME>BaseTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="d5023b57-2dde-4f71-aa2f-255f1cddd823">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F896C834-38EA-4061-B696-060C6651B152">
          <SHORT-NAME>NvM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="b52800ea-fc72-43bc-8a9f-ba33c8f4ed33">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="eee1dc16-dd67-4788-b511-a5df357d9bb2">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="6307de35-5931-4927-8eeb-e0091c62c958">
                  <SHORT-NAME>BaseTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="641f7da7-07de-49e8-8942-6e2b736d3192">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="5150bf1c-c9a2-4d50-8a48-af426deda450">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="796DC628-8415-4958-BB78-AEE099B6973F">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F11EC53B-E825-4BC6-9771-D5D72BBE9140">
          <SHORT-NAME>NvMProxy_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="CF1F6232-7589-415B-A83D-82738DEAEAE0">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DB200800-DD02-4C40-AD3E-0384AA9F2846">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0B158A41-4824-4891-96F1-B18B81A16D35">
      <SHORT-NAME>ModeDeclarationGroup</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DF9CDDC3-102A-4283-A461-40C1E95FD26E">
      <SHORT-NAME>Nexteer</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="869B7B07-52C9-4661-BD35-747C27731B63">
          <SHORT-NAME>Calibrations</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="0525129F-0E66-42B7-9BBE-C4A7FD983E59">
          <SHORT-NAME>CDD_NvMProxy_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="DC462DAF-5ACA-4CE0-9A9A-FD0B107186A1">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="70DDB12D-6498-48B1-9154-FAF57032E966">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="559AFA91-750A-4425-80BE-D037D95F6964">
                  <SHORT-NAME>BaseTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="507D8BD3-6E3E-4666-AA8E-20D20E5F32E2">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="AD925038-B3B3-49FD-8879-4372D479C98B">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="034BEF98-9186-4CEB-B7DC-683797C6CC5D">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7182F3E4-50B7-4F5E-A37C-C1F31AF25970">
          <SHORT-NAME>ComponentTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="A96F0713-E97F-4677-BDA9-B2836A0CF99E">
              <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="62A31D46-E813-44DC-9A1C-03F931C287CD">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A96F0713-E97F-4677-BDA9-B2836A0CF99E">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F5BC336D-7F68-431F-A132-1C9964947D8C">
          <SHORT-NAME>DataTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="172B6DD5-F18F-4595-BAB7-F2215C69DE97">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="69008EEE-C7E6-4D44-B2DF-22752EB17695">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="172FE4F3-EA35-46A2-AF59-FBC3B0B8762D">
              <SHORT-NAME>DataConstrs</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E93F6EFF-381F-456B-9B7F-EC0F9F7B7687">
          <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3127C774-147F-4405-A717-2DDF67A6659E">
          <SHORT-NAME>NvMProxy_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="E95BF695-CA46-44DA-835A-05D94B642589">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="BEC7D1DD-267C-46E0-BEFE-EA71AF00B10D">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="0CBF8DDE-EC9C-4F10-BE93-1D37D7474174">
                  <SHORT-NAME>BaseTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="44B3697D-765C-44EC-923A-0C84D3640EEB">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="9E9C6F28-0F63-48C4-9E71-483E782254DD">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="BB373B43-5CE5-4271-B4F5-DC4EFCA503AA">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6129620B-B6E6-4A91-8F1B-96DD4AEADBB0">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D5B4E095-8F3D-418F-AB06-BD30490B5310">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="5640AB06-D0F8-454F-8946-866C59D5453F">
      <SHORT-NAME>PortInterface</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AA679BAA-8269-487A-BB7A-CB4021A63894">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="312AF810-81CB-4534-BFFF-6B675C5A51D9">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="ADC58AAF-5AA8-4FE0-851C-F87955AB21AF">
      <SHORT-NAME>Units</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="396B00DB-96AE-4B39-AF78-5070808BF689">
      <SHORT-NAME>VehicleProject</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>