<?xml version="1.0" encoding="utf-8"?>
<!--
This file was saved with a tool from Vector Informatik GmbH
-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-0-3.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="01E2384C-4C1C-415B-8BA9-72B840D7231F">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="06FCF889-F5FD-4EE8-BBD3-730673A92728">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="11635ADE-FCAE-444E-B2F9-BC66E23D077A">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7182F3E4-50B7-4F5E-A37C-C1F31AF25970">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="40068D77-2B15-442B-9E6D-32F77D283878">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="758F17C1-5B62-4E5D-9144-BD6C7F02774A">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BBCC0C56-72BE-48A2-A99B-BFFFBCB76918">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="99FD5429-5806-4EA1-858E-83B511F58EBC">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="D9086933-8783-4376-8D36-2DA8273D475D">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="95F17CEC-F00A-406A-9F9D-518FAB8F9B43">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3CD8CE50-C3EA-481C-A3A4-CCE1D8C86677">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="545F0A4E-8CAC-4330-994E-2C09B2B85133">
          <SHORT-NAME>PlatformTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FBA523DA-8900-4005-BD00-554BDEDE2366">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="2B60535D-0057-462F-AF84-F87C746F792C">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="28C1B48B-C376-4921-B7BA-5116C2C104EE">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="F8C80E89-D84D-40B0-B128-609EFBC832B2">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="ACA966E7-2056-4362-8153-260001FE440F">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DF9CDDC3-102A-4283-A461-40C1E95FD26E">
      <SHORT-NAME>Nexteer</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="869B7B07-52C9-4661-BD35-747C27731B63">
          <SHORT-NAME>Calibrations</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="62A31D46-E813-44DC-9A1C-03F931C287CD">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A96F0713-E97F-4677-BDA9-B2836A0CF99E">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F5BC336D-7F68-431F-A132-1C9964947D8C">
          <SHORT-NAME>DataTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="172B6DD5-F18F-4595-BAB7-F2215C69DE97">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="69008EEE-C7E6-4D44-B2DF-22752EB17695">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E93F6EFF-381F-456B-9B7F-EC0F9F7B7687">
          <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6129620B-B6E6-4A91-8F1B-96DD4AEADBB0">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D5B4E095-8F3D-418F-AB06-BD30490B5310">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0234188E-F796-4B7D-B34F-D40DEAA773F1">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0F540107-7666-48E5-9189-881058904F08">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>